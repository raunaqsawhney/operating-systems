# Keil uVision project RTX_Lib_CM.uvproj, settings and files
target CM3_LE (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RTX_CM3 (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM3_LE\BuildLib.scr
  c flags: Optim=4 OneElfS=1
  c define: DBG_MSG
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  group Kernel
    ./SRC/CM/: rt_Task.c rt_System.c rt_Event.c rt_List.c rt_Mailbox.c rt_Semaphore.c rt_Time.c rt_Timer.c rt_Mutex.c rt_Robin.c rt_MemBox.c rt_User.c rt_User.h
  group Config
    ./SRC/CM/: SVC_Table.s HAL_CM3.c
